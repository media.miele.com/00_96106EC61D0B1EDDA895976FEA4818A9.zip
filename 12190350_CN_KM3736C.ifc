Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2023-01-27T09:53:13
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jan 27 09:53:13 2023 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\f48b3eef-d9a2-4950-9563-5773c556083c\cba14c0e-9e45-4571-a9aa-b04e5ab0aa81\ifc * Database version: 5507 * Database creation date: Fri Jan 27 09:53:12 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jan 27 09:53:12 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jan 27 09:53:12 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12190350_CN_KM3736C:26373652_CN_12190350_KM3736C, (2)
In: Default
Type - Material: z_Miele_Design_OBSW
Type - Pset_BuildingElementProxyCommon - Reference: 26373652_CN_12190350_KM3736C
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 26373652_CN_12190350_KM3736C
Material: z_Miele_Design_OBSW, z_Miele_Design_Cast, z_Miele_Design_CLST, z_Miele_Connection_Gas, z_Miele_Connection_Connection_Modul
Pset_BuildingElementProxyCommon - sets with these values: 2
